Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 61f93069-24cd-421a-9d91-b431c44ef2ed, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-07T14:38:34+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12830220_BNF_DAE1530_EDST:28E1530S_BNF_12830220_DAE1530_EDST, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Connection_Connection_Modul, z_Miele_Design_GRGR, z_Miele_Design_Glass
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 532 mm; Height: 326 mm; Depth: 372 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28E1530S_BNF_12830220_DAE1530_EDST; sets with these values: 2
